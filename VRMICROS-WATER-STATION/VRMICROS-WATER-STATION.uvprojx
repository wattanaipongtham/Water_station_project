# Keil uVision project VRMICROS-WATER-STATION.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: VRMICROS-WATER-STATION
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F105xC
  c include: .\Drivers\CMSIS\Device\ST\STM32F1xx\Include;.\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Src
    ./: main.c systemClockConfig.c sysTick.c usart.c ECDO.c
  group Inc
    ./: systemClockConfig.h sysTick.h usart.h GSMCommand.h ECDO.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
